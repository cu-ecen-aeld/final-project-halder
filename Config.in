## package/sysmon/Config.in
```kconfig
config BR2_PACKAGE_SYSMON
    bool "sysmon kernel module, daemon & dashboard"
    help
        System monitoring kernel module for Raspberry Pi 4.
```
